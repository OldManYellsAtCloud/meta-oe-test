PACKAGECONFIG += "disable-sandboxed-libraries"
