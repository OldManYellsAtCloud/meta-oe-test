SUMMARY = "Serialization library for Exceptions and Tracebacks."
LICENSE = "BSD-2-Clause"
LIC_FILES_CHKSUM = "file://LICENSE;md5=f7dab5be9201bbd1740e561e5cee4a3c"

inherit pypi setuptools3

SRC_URI[sha256sum] = "06404c2c9f07f66fee2d7d6ad43accc46f9c3361714d9b8426e7f47e595cd652"
