FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://ptest.cfg"
